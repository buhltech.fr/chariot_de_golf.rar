# Autodesk Inventor part: Sol
## iProperties
Created: 2011-01
Part Number: Sol
Document SubType Name: Modeling
Designer: eric
Density: 1 g/cm^3
Author: eric
## Feature names
1. Extrusion1
