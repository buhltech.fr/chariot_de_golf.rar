# Autodesk Inventor part: sac
## iProperties
Created: 2011-01
Part Number: sac
Document SubType Name: Modeling
Designer: eric
Density: 1 g/cm^3
Author: eric
