# Autodesk Inventor part: 24poignee_femelle_D�faut
## iProperties
Created: 2011-01
Part Number: 24poignee_femelle_D�faut
Document SubType Name: Modeling
Designer: eric
Density: 1 g/cm^3
Mass: 71.4336 g
Surface Area: 665.835 cm^2
Volume: 71.4336 cm^3
Author: eric
## Feature names
1. Base1
