# Autodesk Inventor part: 12Ecrou_freineM5
## iProperties
Created: 2011-01
Part Number: 12Ecrou_freineM5
Document SubType Name: Modeling
Designer: eric
Density: 1 g/cm^3
Mass: 0.198535 g
Surface Area: 2.65723 cm^2
Volume: 0.198535 cm^3
Author: eric
## Feature names
1. Base1
