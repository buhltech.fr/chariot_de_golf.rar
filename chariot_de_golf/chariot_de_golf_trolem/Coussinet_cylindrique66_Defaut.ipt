# Autodesk Inventor part: Coussinet_cylindrique66_D�faut
## iProperties
Created: 2011-01
Part Number: Coussinet_cylindrique66_D�faut
Document SubType Name: Modeling
Designer: eric
Density: 1 g/cm^3
Mass: 4.31228 g
Surface Area: 32.5608 cm^2
Volume: 4.31228 cm^3
Author: eric
## Feature names
1. Base1
