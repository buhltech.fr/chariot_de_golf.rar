# Autodesk Inventor assembly: essieu_avant
## iProperties
Created: 2011-01
Part Number: essieu_avant
Document SubType Name: Assembly
Designer: eric
Author: eric
