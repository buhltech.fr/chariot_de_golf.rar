# Autodesk Inventor assembly: rotor moteur
## iProperties
Created: 2011-01
Part Number: rotor moteur
Document SubType Name: Assembly
Designer: eric
Author: eric
