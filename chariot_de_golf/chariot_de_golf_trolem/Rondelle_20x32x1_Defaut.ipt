# Autodesk Inventor part: Rondelle_20x32x1_D�faut
## iProperties
Created: 2011-01
Part Number: Rondelle_20x32x1_D�faut
Document SubType Name: Modeling
Designer: eric
Density: 1 g/cm^3
Mass: 0.490088 g
Surface Area: 11.4354 cm^2
Volume: 0.490088 cm^3
Author: eric
## Feature names
1. Base1
